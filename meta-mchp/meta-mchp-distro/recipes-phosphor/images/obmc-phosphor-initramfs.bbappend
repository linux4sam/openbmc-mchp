# Clear EXTRA_USERS_PARAMS that may have been set globally 
# (passwd-expire in local.conf).
EXTRA_USERS_PARAMS:pn-obmc-phosphor-initramfs = ""
