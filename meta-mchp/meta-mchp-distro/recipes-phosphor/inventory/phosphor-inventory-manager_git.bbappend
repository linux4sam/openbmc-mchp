DEPENDS:append = " basic-inventory"