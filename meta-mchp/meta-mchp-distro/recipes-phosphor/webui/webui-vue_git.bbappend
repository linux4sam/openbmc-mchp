# TEMPORARY: Use the latest commit before issue
# https://github.com/openbmc/webui-vue/issues/140
# until the issue fix makes it to the webui-vue repo

SRCREV = "8e38779a3623db60c47024510c479b68eb90e05b"

