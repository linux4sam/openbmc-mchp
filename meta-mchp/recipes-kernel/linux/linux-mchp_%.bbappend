FILESEXTRAPATHS:prepend := "${THISDIR}/common:"
SRC_URI += "file://overlays.cfg"