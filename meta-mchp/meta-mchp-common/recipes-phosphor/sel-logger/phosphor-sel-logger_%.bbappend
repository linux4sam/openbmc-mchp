PACKAGECONFIG:append = " log-threshold log-alarm send-to-logger"